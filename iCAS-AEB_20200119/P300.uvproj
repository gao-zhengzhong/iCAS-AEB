# Keil uVision project P300.uvproj, settings and files
target Target 1 (166/167)
  device: XC2364B-40F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE01FFF) XRAM3(0x00F600-0x00FDFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC4FFFF) CLOCK(80000000) MOD167 MODV2
  output: P300 +hex
  group driver
    ./src/driver/: ADC0.c ADC1.c CAN.c CCU60.c CCU61.c GPT1.c GPT2.c IO.c MAIN.c SCS.c Start_V3.A66
  group Fun
    ./src/app/Fun/: adsample.c busline.c Fun.c iso.c
  group mode
    ./src/app/mode control/: ModeControl.c
  group alogrithm
    ./src/app/alogrithm/: aeb.c booster.c energy_recovery.c iCasBrake.c pid.c wire_control.c adas_aeb.c adas_fcw.c
  group app
    ./src/app/adc/: adc_sample.c
    ./src/app/can/: can_com.c
    ./src/app/ccp/: ccp.c
    ./src/app/diagnostic/: FLTD.c FLTM.c
  group interaction
    ./src/interaction/: adc_if.c ccp_if.c eepRom.c pwm.c
  group task
    ./src/app/task/: Task1.c Task2.c Task3.c Task4.c
